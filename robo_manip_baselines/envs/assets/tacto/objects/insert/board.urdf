Commit message: fixed board and spoon env

File: robo_manip_baselines/envs/assets/tacto/objects/insert/board.urdf (robot description, URDF)
Before this commit: robot board, 1 links, 0 joints
Links:
- link board: geometry collision box size=.008 .05 .29; visual box size=.008 .05 .29
